# IAR project GD32H75E_EVAL.ewp, settings and files
configuration GD32H75E (ARM, debug)
  General.OGChipSelectEditMenu: GD32H75ExM GD GD32H75ExM
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 41
  General.FPU2: 7
  ICCARM.CCDefines: GD32H75E
  ICCARM.CCIncludePath2: ..\..\..\GD32H75E_Firmware_Library\CMSIS\GD\GD32H75E\Include; ..\..\..\GD32H75E_Firmware_Library\GD32H75E_standard_peripheral\Include; ..; ..\..\Utilities; ..\..\..\..\Middleware\Third_Party\FreeRTOS-Kernel-11.2.0\include; ..\..\..\..\Middleware\Third_Party\FreeRTOS-Kernel-11.2.0\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..; ..\..\..\..\Middleware\Third_Party\FreeRTOS-Kernel-11.2.0\portable\IAR\ARM_CM4F
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../: gd32h75e_it.c main.c
  group CMSIS
    ../../../GD32H75E_Firmware_Library/CMSIS/GD/GD32H75E/Source/: gd32h75e_err_report.c system_gd32h75e.c
  group Doc
    ../: readme.txt
  group GD32H75E_EVAL
    ../../Utilities/: gd32h75ey_eval.c
  group GD32H75E_Peripherals
    ../../../GD32H75E_Firmware_Library/GD32H75E_standard_peripheral/Source/: gd32h75e_adc.c gd32h75e_can.c gd32h75e_cmp.c gd32h75e_crc.c gd32h75e_ctc.c gd32h75e_dac.c gd32h75e_dbg.c gd32h75e_dma.c gd32h75e_edout.c gd32h75e_efuse.c gd32h75e_exmc.c gd32h75e_exti.c gd32h75e_fac.c gd32h75e_fmc.c gd32h75e_fwdgt.c gd32h75e_gpio.c gd32h75e_hpdf.c gd32h75e_i2c.c gd32h75e_lpdts.c gd32h75e_mdma.c gd32h75e_misc.c gd32h75e_ospi.c gd32h75e_ospim.c gd32h75e_pmu.c gd32h75e_rameccmu.c gd32h75e_rcu.c gd32h75e_rtc.c gd32h75e_spi.c gd32h75e_syscfg.c gd32h75e_timer.c gd32h75e_tmu.c gd32h75e_trigsel.c gd32h75e_trng.c gd32h75e_usart.c gd32h75e_vref.c gd32h75e_wwdgt.c
  group Startup
    ../../../GD32H75E_Firmware_Library/CMSIS/GD/GD32H75E/Source/IAR/: startup_gd32h75e.s
  group FreeRTOS
    ../../../../Middleware/Third_Party/FreeRTOS-Kernel-11.2.0/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../Middleware/Third_Party/FreeRTOS-Kernel-11.2.0/portable/MemMang/: heap_4.c
  group FreeRTOS_Port
    ../../../../Middleware/Third_Party/FreeRTOS-Kernel-11.2.0/portable/IAR/ARM_CM4F/: port.c portasm.s
