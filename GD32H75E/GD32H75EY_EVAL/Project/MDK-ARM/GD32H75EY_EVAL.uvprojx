# Keil uVision project GD32H75EY_EVAL.uvprojx, settings and files
target GD32H75EY_EVAL (6140000::V6.14::ARMCLANG)
  device: GD32H75EYMJ6 GigaDevice
  pack: GigaDevice.GD32H75E_DFP.0.0.1
  cpu: IRAM(0x24000000,0x000D0000) IRAM2(0x00000000,0x00010000) IROM(0x08000000,0x03C0000) XRAM(0x20000000,0x00020000) XRAM2(0x30000000,0x00004000) XRAM3(0x30004000,0x00004000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32H75E
  c include: ..\;..\..\..\GD32H75E_Firmware_Library\CMSIS\GD\GD32H75E\Include;..\..\..\GD32H75E_Firmware_Library\GD32H75E_standard_peripheral\Include;..\..\Utilities;..\..\..\..\Middleware\Third_Party\FreeRTOS-Kernel-11.2.0\include;..\..\..\..\Middleware\Third_Party\FreeRTOS-Kernel-11.2.0\portable\GCC\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x3c0000
  memory RVCT6: RAM 0x20000000 size 0x20000
  memory RVCT7: RAM 0x30000000 size 0x4000
  memory RVCT8: RAM 0x30004000 size 0x4000
  memory RVCT9: RAM 0x24000000 size 0xd0000
  memory RVCT10: RAM 0x0 size 0x10000
  group Application
    ../: main.c gd32h75e_it.c
  group CMSIS
    ../../../GD32H75E_Firmware_Library/CMSIS/GD/GD32H75E/Source/: system_gd32h75e.c gd32h75e_err_report.c
  group GD32H75E_Peripherals
    ../../../GD32H75E_Firmware_Library/GD32H75E_standard_peripheral/Source/: gd32h75e_adc.c gd32h75e_can.c gd32h75e_cmp.c gd32h75e_crc.c gd32h75e_ctc.c gd32h75e_dac.c gd32h75e_dbg.c gd32h75e_dma.c gd32h75e_edout.c gd32h75e_efuse.c gd32h75e_exmc.c gd32h75e_exti.c gd32h75e_fac.c gd32h75e_fmc.c gd32h75e_fwdgt.c gd32h75e_gpio.c gd32h75e_hpdf.c gd32h75e_i2c.c gd32h75e_lpdts.c gd32h75e_mdma.c gd32h75e_misc.c gd32h75e_ospi.c gd32h75e_ospim.c gd32h75e_pmu.c gd32h75e_rameccmu.c gd32h75e_rcu.c gd32h75e_rtc.c gd32h75e_spi.c gd32h75e_syscfg.c gd32h75e_timer.c gd32h75e_tmu.c gd32h75e_trigsel.c gd32h75e_trng.c gd32h75e_usart.c gd32h75e_vref.c gd32h75e_wwdgt.c
  group GD32H75E_EVAL
    ../../Utilities/: gd32h75ey_eval.c
  group Startup
    ../../../GD32H75E_Firmware_Library/CMSIS/GD/GD32H75E/Source/ARM/: startup_gd32h75e.s
  group FreeRTOS
    ../../../../Middleware/Third_Party/FreeRTOS-Kernel-11.2.0/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../Middleware/Third_Party/FreeRTOS-Kernel-11.2.0/portable/MemMang/: heap_4.c
  group FreeRTOS_Port
    ../../../../Middleware/Third_Party/FreeRTOS-Kernel-11.2.0/portable/GCC/ARM_CM4F/: port.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.5.0
