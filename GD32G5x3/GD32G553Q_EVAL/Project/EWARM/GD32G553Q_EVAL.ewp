# IAR project GD32G553Q_EVAL.ewp, settings and files
configuration GD32G5x3 (ARM, debug)
  General.OGChipSelectEditMenu: GD32G553xE GD GD32G553xE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: GD32G553
  ICCARM.CCIncludePath2: ..; ..\..\Utilities; ..\..\..\GD32G5x3_Firmware_Library\GD32G5x3_standard_peripheral\Include; ..\..\..\GD32G5x3_Firmware_Library\CMSIS\GD\GD32G5x3\Include; ..\..\..\GD32G5x3_Firmware_Library\CMSIS; ..\..\..\..\Middleware\Third_Party\FreeRTOS-Kernel-11.2.0\include; ..\..\..\..\Middleware\Third_Party\FreeRTOS-Kernel-11.2.0\portable\IAR\ARM_CM33_NTZ\non_secure
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..; ..\..\..\..\Middleware\Third_Party\FreeRTOS-Kernel-11.2.0\include; ..\..\..\..\Middleware\Third_Party\FreeRTOS-Kernel-11.2.0\portable\IAR\ARM_CM33_NTZ\non_secure
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../: gd32g5x3_it.c main.c
  group FreeRTOS_Port
    ../../../../Middleware/Third_Party/FreeRTOS-Kernel-11.2.0/portable/IAR/ARM_CM33_NTZ/non_secure/: port.c portasm.s
  group FreeRTOS_Kernel
    ../../../../Middleware/Third_Party/FreeRTOS-Kernel-11.2.0/: list.c queue.c tasks.c timers.c
    ../../../../Middleware/Third_Party/FreeRTOS-Kernel-11.2.0/portable/MemMang/: heap_4.c
  group CMSIS
    ../../../GD32G5x3_Firmware_Library/CMSIS/GD/GD32G5x3/Source/: system_gd32g5x3.c
  group Doc
    ../: readme.txt
  group GD32G5x3_EVAL
    ../../Utilities/: gd32g553q_eval.c
  group GD32G5x3_Peripherals
    ../../../GD32G5x3_Firmware_Library/GD32G5x3_standard_peripheral/Source/: gd32g5x3_adc.c gd32g5x3_can.c gd32g5x3_cau.c gd32g5x3_cau_aes.c gd32g5x3_cau_des.c gd32g5x3_cau_tdes.c gd32g5x3_cla.c gd32g5x3_cmp.c gd32g5x3_cpdm.c gd32g5x3_crc.c gd32g5x3_dac.c gd32g5x3_dbg.c gd32g5x3_dma.c gd32g5x3_exmc.c gd32g5x3_exti.c gd32g5x3_fac.c gd32g5x3_fft.c gd32g5x3_fmc.c gd32g5x3_fmc_ramfunc.c gd32g5x3_fwdgt.c gd32g5x3_gpio.c gd32g5x3_hpdf.c gd32g5x3_hrtimer.c gd32g5x3_i2c.c gd32g5x3_lptimer.c gd32g5x3_misc.c gd32g5x3_pmu.c gd32g5x3_qspi.c gd32g5x3_rcu.c gd32g5x3_rtc.c gd32g5x3_spi.c gd32g5x3_syscfg.c gd32g5x3_timer.c gd32g5x3_tmu.c gd32g5x3_trigsel.c gd32g5x3_trng.c gd32g5x3_usart.c gd32g5x3_vref.c gd32g5x3_wwdgt.c
  group Startup
    ../../../GD32G5x3_Firmware_Library/CMSIS/GD/GD32G5x3/Source/IAR/: startup_gd32g5x3.s
