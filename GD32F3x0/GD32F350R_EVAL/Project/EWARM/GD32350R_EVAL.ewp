# IAR project GD32350R_EVAL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32F350xB GD GD32F350xB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F350
  ICCARM.CCIncludePath2: ..; ..\..\Utilities; ..\..\..\GD32F3x0_Firmware_Library\CMSIS\GD\GD32F3x0\Include; ..\..\..\GD32F3x0_Firmware_Library\GD32F3x0_standard_peripheral\Include; ..\..\..\..\Middleware\Third_Party\FreeRTOS-Kernel-11.2.0\include; ..\..\..\..\Middleware\Third_Party\FreeRTOS-Kernel-11.2.0\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..; ..\..\..\..\Middleware\Third_Party\FreeRTOS-Kernel-11.2.0\include; ..\..\..\..\Middleware\Third_Party\FreeRTOS-Kernel-11.2.0\portable\IAR\ARM_CM4F
  OBJCOPY.OOCOutputFile: GD32350R_EVAL.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 0
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group Application
    ../: gd32f3x0_it.c main.c
  group CMSIS
    ../../../GD32F3x0_Firmware_Library/CMSIS/GD/GD32F3x0/Source/: system_gd32f3x0.c
  group Doc
    ../: readme.txt
  group FreeRTOS
    ../../../../Middleware/Third_Party/FreeRTOS-Kernel-11.2.0/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../Middleware/Third_Party/FreeRTOS-Kernel-11.2.0/portable/MemMang/: heap_4.c
    ../../../../Middleware/Third_Party/FreeRTOS-Kernel-11.2.0/portable/IAR/ARM_CM4F/: port.c portasm.s
  group GD32F3x0_EVAL
    ../../Utilities/: gd32f350r_eval.c
  group GD32F3x0_Peripherals
    ../../../GD32F3x0_Firmware_Library/GD32F3x0_standard_peripheral/Source/: gd32f3x0_adc.c gd32f3x0_cec.c gd32f3x0_cmp.c gd32f3x0_crc.c gd32f3x0_ctc.c gd32f3x0_dac.c gd32f3x0_dbg.c gd32f3x0_dma.c gd32f3x0_exti.c gd32f3x0_fmc.c gd32f3x0_fwdgt.c gd32f3x0_gpio.c gd32f3x0_i2c.c gd32f3x0_misc.c gd32f3x0_pmu.c gd32f3x0_rcu.c gd32f3x0_rtc.c gd32f3x0_spi.c gd32f3x0_syscfg.c gd32f3x0_timer.c gd32f3x0_tsi.c gd32f3x0_usart.c gd32f3x0_wwdgt.c
  group Startup
    ../../../GD32F3x0_Firmware_Library/CMSIS/GD/GD32F3x0/Source/IAR/: startup_gd32f3x0.s
