# Keil uVision project GD32F5HCR_EVAL.uvprojx, settings and files
target GD32F5HCR_EVAL (6160000::V6.16::ARMCLANG)
  device: GD32F5HCRI GigaDevice
  pack: GigaDevice.GD32W51x_F5HC_DFP.1.0.0
  cpu: IRAM(0x20000000,0x50000) IRAM2(0x30000000,0x50000) IROM(0x08000000,0x0200000) IROM2(0x0C000000,0x0200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32F5HC,SYS_NS,FW_DEBUG_ERR_REPORT
  c include: ..\..\..\GD32W51x_F5HC_Firmware_Library\CMSIS;..\..\..\GD32W51x_F5HC_Firmware_Library\CMSIS\GD\GD32W51x_F5HC\Include;..\..\..\GD32W51x_F5HC_Firmware_Library\GD32W51x_F5HC_standard_peripheral\Include;..\..\Utilities;..\;..\..\..\..\Middleware\Third_Party\FreeRTOS-Kernel-11.2.0\include;..\..\..\..\Middleware\Third_Party\FreeRTOS-Kernel-11.2.0\portable\GCC\ARM_CM33_NTZ\non_secure;..\..\..\..\Middleware\Third_Party\FreeRTOS-Kernel-11.2.0\portable\MemMang
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT5: ROM 0xc000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x50000
  memory RVCT10: RAM 0x30000000 size 0x50000
  group Application
    ../: main.c gd32w51x_f5hc_it.c
  group CMSIS
    ../../../GD32W51x_F5HC_Firmware_Library/CMSIS/GD/GD32W51x_F5HC/Source/: gd32w51x_f5hc_err_report.c system_gd32w51x_f5hc.c
  group GD32F5HC_Peripheral
    ../../../GD32W51x_F5HC_Firmware_Library/GD32W51x_F5HC_standard_peripheral/Source/: gd32w51x_f5hc_adc.c gd32w51x_f5hc_cau.c gd32w51x_f5hc_cau_aes.c gd32w51x_f5hc_cau_des.c gd32w51x_f5hc_cau_tdes.c gd32w51x_f5hc_crc.c gd32w51x_f5hc_ctc.c gd32w51x_f5hc_dbg.c gd32w51x_f5hc_dci.c gd32w51x_f5hc_dma.c gd32w51x_f5hc_efuse.c gd32w51x_f5hc_exti.c gd32w51x_f5hc_fmc.c gd32w51x_f5hc_fwdgt.c gd32w51x_f5hc_gpio.c gd32w51x_f5hc_hau.c gd32w51x_f5hc_hau_sha_md5.c gd32w51x_f5hc_hpdf.c gd32w51x_f5hc_i2c.c gd32w51x_f5hc_icache.c gd32w51x_f5hc_misc.c gd32w51x_f5hc_pkcau.c gd32w51x_f5hc_pmu.c gd32w51x_f5hc_qspi.c gd32w51x_f5hc_rcu.c gd32w51x_f5hc_rtc.c gd32w51x_f5hc_sdio.c gd32w51x_f5hc_spi.c gd32w51x_f5hc_sqpi.c gd32w51x_f5hc_syscfg.c gd32w51x_f5hc_timer.c gd32w51x_f5hc_trng.c gd32w51x_f5hc_tsi.c gd32w51x_f5hc_tzpcu.c gd32w51x_f5hc_usart.c gd32w51x_f5hc_wwdgt.c
  group GD32F5HC_EVAL
    ../../Utilities/: gd32f5hcr_eval.c
  group FreeRTOS
    ../../../../Middleware/Third_Party/FreeRTOS-Kernel-11.2.0/: list.c queue.c tasks.c timers.c event_groups.c
    ../../../../Middleware/Third_Party/FreeRTOS-Kernel-11.2.0/portable/MemMang/: heap_4.c
  group FreeRTOS_Port
    ../../../../Middleware/Third_Party/FreeRTOS-Kernel-11.2.0/portable/GCC/ARM_CM33_NTZ/non_secure/: mpu_wrappers_v2_asm.c port.c portasm.c
  group Startup
    ../../../GD32W51x_F5HC_Firmware_Library/CMSIS/GD/GD32W51x_F5HC/Source/ARM/: startup_gd32f5hc.s
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.3.0
