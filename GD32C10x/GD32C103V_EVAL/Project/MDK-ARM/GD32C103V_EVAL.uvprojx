# Keil uVision project GD32C103V_EVAL.uvprojx, settings and files
target GD32C103V_EVAL (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32C103VB GigaDevice
  pack: GigaDevice.GD32C10x_DFP.1.5.0
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(8000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32C10X
  c include: ..\;..\..\..\GD32C10x_Firmware_Library\CMSIS;..\..\..\GD32C10x_Firmware_Library\CMSIS\GD\GD32C10x\Include;..\..\..\GD32C10x_Firmware_Library\GD32C10x_standard_peripheral\Include;..\..\Utilities;..\..\Utilities\LCD_Commom;..\..\..\..\Middleware\Third_Party\FreeRTOS-Kernel-11.2.0\include;..\..\..\..\Middleware\Third_Party\FreeRTOS-Kernel-11.2.0\portable\RVDS\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../: main.c gd32c10x_it.c
  group CMSIS
    ../../../GD32C10x_Firmware_Library/CMSIS/GD/GD32C10x/Source/: system_gd32c10x.c
  group Peripherals
    ../../../GD32C10x_Firmware_Library/GD32C10x_standard_peripheral/Source/: gd32c10x_adc.c gd32c10x_bkp.c gd32c10x_can.c gd32c10x_crc.c gd32c10x_ctc.c gd32c10x_dac.c gd32c10x_dbg.c gd32c10x_dma.c gd32c10x_exmc.c gd32c10x_exti.c gd32c10x_fmc.c gd32c10x_fwdgt.c gd32c10x_gpio.c gd32c10x_i2c.c gd32c10x_misc.c gd32c10x_pmu.c gd32c10x_rcu.c gd32c10x_rtc.c gd32c10x_spi.c gd32c10x_timer.c gd32c10x_usart.c gd32c10x_wwdgt.c
  group Startup
    ../../../GD32C10x_Firmware_Library/CMSIS/GD/GD32C10x/Source/ARM/: startup_gd32c10x.s
  group Utilities
    ../../Utilities/: gd32c103v_eval.c gd32c103v_lcd_eval.c
    ../../Utilities/LCD_Commom/: lcd_font.c
  group FreeRTOS
    ../../../../Middleware/Third_Party/FreeRTOS-Kernel-11.2.0/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../Middleware/Third_Party/FreeRTOS-Kernel-11.2.0/portable/MemMang/: heap_4.c
    ../../../../Middleware/Third_Party/FreeRTOS-Kernel-11.2.0/portable/RVDS/ARM_CM4F/: port.c
software components: CMSIS:CORE 5.3.0
