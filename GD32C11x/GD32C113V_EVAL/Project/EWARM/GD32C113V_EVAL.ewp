# IAR project GD32C113V_EVAL.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: GD32C113xB GD GD32C113xB
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32C11X
  ICCARM.CCIncludePath2: ..\..\..\GD32C11x_Firmware_Library\CMSIS; ..\..\..\GD32C11x_Firmware_Library\GD32C11x_standard_peripheral\Include; ..\..\..\GD32C11x_Firmware_Library\CMSIS\GD\GD32C11x\Include; ..; ..\..\Utilities; ..\..\Utilities\LCD_Commom; ..\..\..\..\Middleware\Third_Party\FreeRTOS-Kernel-11.2.0\include; ..\..\..\..\Middleware\Third_Party\FreeRTOS-Kernel-11.2.0\portable\IAR\ARM_CM4F
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..; ..\..\..\..\Middleware\Third_Party\FreeRTOS-Kernel-11.2.0\portable\IAR\ARM_CM4F
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../: gd32c11x_it.c main.c
  group CMSIS
    ../../../GD32C11x_Firmware_Library/CMSIS/GD/GD32C11x/Source/: system_gd32c11x.c
  group Doc
    ../: readme.txt
  group FreeRTOS
    ../../../../Middleware/Third_Party/FreeRTOS-Kernel-11.2.0/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../Middleware/Third_Party/FreeRTOS-Kernel-11.2.0/portable/MemMang/: heap_4.c
    ../../../../Middleware/Third_Party/FreeRTOS-Kernel-11.2.0/portable/IAR/ARM_CM4F/: port.c portasm.s
  group GD32C11x_EVAL
    ../../Utilities/: gd32c113v_eval.c
  group GD32C11x_Peripherals
    ../../../GD32C11x_Firmware_Library/GD32C11x_standard_peripheral/Source/: gd32c11x_adc.c gd32c11x_bkp.c gd32c11x_can.c gd32c11x_crc.c gd32c11x_ctc.c gd32c11x_dac.c gd32c11x_dbg.c gd32c11x_dma.c gd32c11x_exmc.c gd32c11x_exti.c gd32c11x_fmc.c gd32c11x_fwdgt.c gd32c11x_gpio.c gd32c11x_i2c.c gd32c11x_misc.c gd32c11x_pmu.c gd32c11x_rcu.c gd32c11x_rtc.c gd32c11x_spi.c gd32c11x_timer.c gd32c11x_usart.c gd32c11x_wwdgt.c
  group Startup
    ../../../GD32C11x_Firmware_Library/CMSIS/GD/GD32C11x/Source/IAR/: startup_gd32c11x.s
