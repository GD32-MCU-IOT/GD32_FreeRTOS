# Keil uVision project GD32C113V_EVAL.uvprojx, settings and files
target GD32C113V_EVAL (6160000::V6.16::ARMCLANG)
  device: GD32C113VB GigaDevice
  pack: GigaDevice.GD32C11x_DFP.1.4.0
  cpu: IRAM(0x20000000,0x08000) IROM(0x08000000,0x020000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER,GD32C11X
  c include: ..\;..\..\..\GD32C11x_Firmware_Library\CMSIS;..\..\..\GD32C11x_Firmware_Library\CMSIS\GD\GD32C11x\Include;..\..\..\GD32C11x_Firmware_Library\GD32C11x_standard_peripheral\Include;..\..\Utilities;..\..\Utilities\LCD_Commom;..\..\..\..\Middleware\Third_Party\FreeRTOS-Kernel-11.2.0\include;..\..\..\..\Middleware\Third_Party\FreeRTOS-Kernel-11.2.0\portable\GCC\ARM_CM4F
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Application
    ../: main.c gd32c11x_it.c
  group CMSIS
    ../../../GD32C11x_Firmware_Library/CMSIS/GD/GD32C11x/Source/: system_gd32c11x.c
  group Peripherals
    ../../../GD32C11x_Firmware_Library/GD32C11x_standard_peripheral/Source/: gd32c11x_adc.c gd32c11x_bkp.c gd32c11x_can.c gd32c11x_crc.c gd32c11x_ctc.c gd32c11x_dac.c gd32c11x_dbg.c gd32c11x_dma.c gd32c11x_exmc.c gd32c11x_exti.c gd32c11x_fmc.c gd32c11x_fwdgt.c gd32c11x_gpio.c gd32c11x_i2c.c gd32c11x_misc.c gd32c11x_pmu.c gd32c11x_rcu.c gd32c11x_rtc.c gd32c11x_spi.c gd32c11x_timer.c gd32c11x_usart.c gd32c11x_wwdgt.c
  group Startup
    ../../../GD32C11x_Firmware_Library/CMSIS/GD/GD32C11x/Source/ARM/: startup_gd32c11x.s
  group Utilities
    ../../Utilities/: gd32c113v_eval.c gd32c113v_lcd_eval.c
    ../../Utilities/LCD_Commom/: lcd_font.c
  group FreeRTOS
    ../../../../Middleware/Third_Party/FreeRTOS-Kernel-11.2.0/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../Middleware/Third_Party/FreeRTOS-Kernel-11.2.0/portable/MemMang/: heap_4.c
    ../../../../Middleware/Third_Party/FreeRTOS-Kernel-11.2.0/portable/GCC/ARM_CM4F/: port.c
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.3.0
