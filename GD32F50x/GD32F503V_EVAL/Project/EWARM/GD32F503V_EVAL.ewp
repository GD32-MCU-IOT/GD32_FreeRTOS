# IAR project GD32F503V_EVAL.ewp, settings and files
configuration GD32F50x (ARM)
  General.OGChipSelectEditMenu: GD32F503xG GD GD32F503xG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; GD32F50X; GD32F503; FW_DEBUG_ERR_REPORT
  ICCARM.CCIncludePath2: ..\..\..\GD32F50x_Firmware_Library\CMSIS\GD\GD32F50x\Include; ..\..\Utilities; ..; ..\..\..\GD32F50x_Firmware_Library\GD32F50x_standard_peripheral\Include; ..\..\..\..\Middleware\Third_Party\FreeRTOS-Kernel-11.2.0\include; ..\..\..\..\Middleware\Third_Party\FreeRTOS-Kernel-11.2.0\portable\IAR\ARM_CM33_NTZ\non_secure
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..; ..\..\..\..\Middleware\Third_Party\FreeRTOS-Kernel-11.2.0\include; ..\..\..\..\Middleware\Third_Party\FreeRTOS-Kernel-11.2.0\portable\IAR\ARM_CM33_NTZ\non_secure
  OBJCOPY.OOCOutputFile: GD32F503V_EVAL.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../: gd32f50x_it.c main.c
  group CMSIS
    ../../../GD32F50x_Firmware_Library/CMSIS/GD/GD32F50x/Source/: gd32f50x_err_report.c system_gd32f50x.c
  group Doc
    ../: readme.txt
  group FreeRTOS
    ../../../../Middleware/Third_Party/FreeRTOS-Kernel-11.2.0/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../Middleware/Third_Party/FreeRTOS-Kernel-11.2.0/portable/MemMang/: heap_4.c
  group FreeRTOS_Port
    ../../../../Middleware/Third_Party/FreeRTOS-Kernel-11.2.0/portable/IAR/ARM_CM33_NTZ/non_secure/: mpu_wrappers_v2_asm.S port.c portasm.s
  group GD32F50x_EVAL
    ../../Utilities/: gd32f503v_eval.c
  group GD32F50x_Peripherals
    ../../../GD32F50x_Firmware_Library/GD32F50x_standard_peripheral/Source/: gd32f50x_adc.c gd32f50x_bkp.c gd32f50x_can.c gd32f50x_cau.c gd32f50x_cmp.c gd32f50x_crc.c gd32f50x_ctc.c gd32f50x_dac.c gd32f50x_dbg.c gd32f50x_dma.c gd32f50x_exmc.c gd32f50x_exti.c gd32f50x_fmc.c gd32f50x_fwdgt.c gd32f50x_gpio.c gd32f50x_hau.c gd32f50x_i2c.c gd32f50x_misc.c gd32f50x_pmu.c gd32f50x_rcu.c gd32f50x_rtc.c gd32f50x_spi.c gd32f50x_syscfg.c gd32f50x_timer.c gd32f50x_trigsel.c gd32f50x_trng.c gd32f50x_usart.c gd32f50x_wwdgt.c
  group Startup
    ../../../GD32F50x_Firmware_Library/CMSIS/GD/GD32F50x/Source/IAR/: startup_gd32f50x.s
