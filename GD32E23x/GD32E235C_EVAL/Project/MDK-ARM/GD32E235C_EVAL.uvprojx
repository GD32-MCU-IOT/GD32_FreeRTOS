# Keil uVision project GD32E235C_EVAL.uvprojx, settings and files
target GD32E235C_EVAL (6120000::V6.12::.\ARMCLANG)
  device: GD32E235CB GigaDevice
  pack: GigaDevice.GD32E23x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x0002000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: GD32E235C_EVAL
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: GD32E235
  c include: ..\\..\\..\\GD32E23x_Firmware_Library\CMSIS\GD\GD32E23x\Include;..\\..\\Utilities;..\\..\\..\\GD32E23x_Firmware_Library\GD32E23x_standard_peripheral\Include;..\;..\\..\\..\\..\\Middleware\Third_Party\FreeRTOS-Kernel-11.2.0\include;..\\..\\..\\..\\Middleware\Third_Party\FreeRTOS-Kernel-11.2.0\portable\GCC\ARM_CM23_NTZ\non_secure
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application
    ../: main.c gd32e23x_it.c
  group FreeRTOS
    ../../../../Middleware/Third_Party/FreeRTOS-Kernel-11.2.0/: tasks.c queue.c list.c timers.c event_groups.c stream_buffer.c croutine.c
    ../../../../Middleware/Third_Party/FreeRTOS-Kernel-11.2.0/portable/MemMang/: heap_4.c
    ../../../../Middleware/Third_Party/FreeRTOS-Kernel-11.2.0/portable/GCC/ARM_CM23_NTZ/non_secure/: port.c portasm.c
  group CMSIS
    ..//..//..//GD32E23x_Firmware_Library/CMSIS/GD/GD32E23x/Source/: system_gd32e23x.c
  group GD32E23x_Peripherals
    ..//..//..//GD32E23x_Firmware_Library/GD32E23x_standard_peripheral/Source/: gd32e23x_adc.c gd32e23x_cmp.c gd32e23x_crc.c gd32e23x_dbg.c gd32e23x_dma.c gd32e23x_exti.c gd32e23x_fmc.c gd32e23x_fwdgt.c gd32e23x_gpio.c gd32e23x_i2c.c gd32e23x_misc.c gd32e23x_pmu.c gd32e23x_rcu.c gd32e23x_rtc.c gd32e23x_spi.c gd32e23x_syscfg.c gd32e23x_timer.c gd32e23x_usart.c gd32e23x_wwdgt.c
  group GD32E235_EVAL
    ..//..//Utilities/: gd32e235c_eval.c
  group Startup
    ..//..//..//GD32E23x_Firmware_Library/CMSIS/GD/GD32E23x/Source/ARM/: startup_gd32e23x.s
  group Doc
    ../: readme.txt
software components: CMSIS:CORE 5.0.2
