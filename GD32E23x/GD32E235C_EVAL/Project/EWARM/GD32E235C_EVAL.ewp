# IAR project GD32E235C_EVAL.ewp, settings and files
configuration GD32E235 (ARM, debug)
  General.OGChipSelectEditMenu: GD32E235x8 GD GD32E235x8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: GD32E235
  ICCARM.CCIncludePath2: ..\..\..\GD32E23x_Firmware_Library\GD32E23x_standard_peripheral\Include; ..\..\Utilities; ..; ..\..\..\GD32E23x_Firmware_Library\CMSIS\GD\GD32E23x\Include; ..\..\..\..\Middleware\Third_Party\FreeRTOS-Kernel-11.2.0\include; ..\..\..\..\Middleware\Third_Party\FreeRTOS-Kernel-11.2.0\portable\IAR\ARM_CM23_NTZ\non_secure
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..; ..\..\..\GD32E23x_Firmware_Library\CMSIS; ..\..\..\..\Middleware\Third_Party\FreeRTOS-Kernel-11.2.0\include; ..\..\..\..\Middleware\Third_Party\FreeRTOS-Kernel-11.2.0\portable\IAR\ARM_CM23_NTZ\non_secure
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: GD32E235x8_freertos.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../: gd32e23x_it.c main.c
  group FreeRTOS
    ../../../../Middleware/Third_Party/FreeRTOS-Kernel-11.2.0/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../Middleware/Third_Party/FreeRTOS-Kernel-11.2.0/portable/MemMang/: heap_4.c
    ../../../../Middleware/Third_Party/FreeRTOS-Kernel-11.2.0/portable/IAR/ARM_CM23_NTZ/non_secure/: port.c portasm.s
  group CMSIS
    ../../../GD32E23x_Firmware_Library/CMSIS/GD/GD32E23x/Source/: system_gd32e23x.c
  group Doc
    ../: readme.txt
  group GD32E235_EVAL
    ../../Utilities/: gd32e235c_eval.c
  group GD32E23x_Peripherals
    ../../../GD32E23x_Firmware_Library/GD32E23x_standard_peripheral/Source/: gd32e23x_adc.c gd32e23x_cmp.c gd32e23x_crc.c gd32e23x_dbg.c gd32e23x_dma.c gd32e23x_exti.c gd32e23x_fmc.c gd32e23x_fwdgt.c gd32e23x_gpio.c gd32e23x_i2c.c gd32e23x_misc.c gd32e23x_pmu.c gd32e23x_rcu.c gd32e23x_rtc.c gd32e23x_spi.c gd32e23x_syscfg.c gd32e23x_timer.c gd32e23x_usart.c gd32e23x_wwdgt.c
  group Startup
    ../../../GD32E23x_Firmware_Library/CMSIS/GD/GD32E23x/Source/IAR/: startup_gd32e23x.s
