# Keil uVision project GD32207I_EVAL.uvprojx, settings and files
target GD32207I_EVAL (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F207IK GigaDevice
  cpu: IRAM(0x20000000-0x2003FFFF) IROM(0x08000000-0x082FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: Project +hex
  c flags: OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,GD32F20X_CL
  c include: ..\;..\..\..\GD32F20x_Firmware_Library\CMSIS\GD\GD32F20x\Include;..\..\..\GD32F20x_Firmware_Library\CMSIS;..\..\..\GD32F20x_Firmware_Library\GD32F20x_standard_peripheral\Include;..\..\Utilities;..\..\..\..\Middleware\Third_Party\FreeRTOS-Kernel-11.2.0\include;..\..\..\..\Middleware\Third_Party\FreeRTOS-Kernel-11.2.0\portable\RVDS\ARM_CM3
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x300000
  memory RVCT9: RAM 0x20000000 size 0x40000
  group Application
    ../: main.c gd32f20x_it.c
  group CMSIS
    ../../../GD32F20x_Firmware_Library/CMSIS/GD/GD32F20x/Source/: system_gd32f20x.c
  group GD32F20x_Peripherals
    ../../../GD32F20x_Firmware_Library/GD32F20x_standard_peripheral/Source/: gd32f20x_exti.c gd32f20x_gpio.c gd32f20x_misc.c gd32f20x_rcu.c gd32f20x_usart.c
  group GD32F207I_EVAL
    ../../Utilities/: gd32f207i_eval.c
  group FreeRTOS
    ../../../../Middleware/Third_Party/FreeRTOS-Kernel-11.2.0/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../../../../Middleware/Third_Party/FreeRTOS-Kernel-11.2.0/portable/MemMang/: heap_4.c
    ../../../../Middleware/Third_Party/FreeRTOS-Kernel-11.2.0/portable/RVDS/ARM_CM3/: port.c
  group Startup
    ../../../GD32F20x_Firmware_Library/CMSIS/GD/GD32F20x/Source/ARM/: startup_gd32f20x_cl.s
  group Doc
    ../: readme.txt
