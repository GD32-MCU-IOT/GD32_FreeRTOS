# Keil uVision project GD32C231C_EVAL.uvprojx, settings and files
target GD32C231C_EVAL (6160000::V6.16::ARMCLANG)
  device: GD32C231C8 GigaDevice
  pack: GigaDevice.GD32C2x1_DFP.1.1.0
  cpu: IRAM(0x20000000,0x0003000) IROM(0x08000000,0x0010000) CPUTYPE("Cortex-M23") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=7 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=3
  c define: USE_STDPERIPH_DRIVER
  c include: ..\..\..\GD32C2x1_Firmware_Library\CMSIS\GD\GD32C2x1\Include;..\..\..\GD32C2x1_Firmware_Library\GD32C2x1_standard_peripheral\Include;..\..\Utilities;..\;..\..\..\..\Middleware\Third_Party\FreeRTOS-Kernel-11.2.0\include;..\..\..\..\Middleware\Third_Party\FreeRTOS-Kernel-11.2.0\portable\GCC\ARM_CM23_NTZ\non_secure
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x3000
  group Application
    ../: main.c gd32c2x1_it.c
  group CMSIS
    ../../../GD32C2x1_Firmware_Library/CMSIS/GD/GD32C2x1/Source/: system_gd32c2x1.c gd32c2x1_err_report.c
  group GD32C2x1_Peripherals
    ../../../GD32C2x1_Firmware_Library/GD32C2x1_standard_peripheral/Source/: gd32c2x1_adc.c gd32c2x1_cmp.c gd32c2x1_crc.c gd32c2x1_dbg.c gd32c2x1_dma.c gd32c2x1_exti.c gd32c2x1_fmc.c gd32c2x1_fwdgt.c gd32c2x1_gpio.c gd32c2x1_i2c.c gd32c2x1_misc.c gd32c2x1_pmu.c gd32c2x1_rcu.c gd32c2x1_rtc.c gd32c2x1_spi.c gd32c2x1_syscfg.c gd32c2x1_timer.c gd32c2x1_usart.c gd32c2x1_wwdgt.c
  group GD32C2x1_EVAL
    ../../Utilities/: gd32c231c_eval.c
  group Startup
    ../../../GD32C2x1_Firmware_Library/CMSIS/GD/GD32C2x1/Source/ARM/: startup_gd32c231_221.s
  group FreeRTOS
    ../../../../Middleware/Third_Party/FreeRTOS-Kernel-11.2.0/: tasks.c queue.c list.c timers.c event_groups.c stream_buffer.c croutine.c
    ../../../../Middleware/Third_Party/FreeRTOS-Kernel-11.2.0/portable/MemMang/: heap_4.c
    ../../../../Middleware/Third_Party/FreeRTOS-Kernel-11.2.0/portable/GCC/ARM_CM23_NTZ/non_secure/: port.c portasm.c
software components: CMSIS:CORE 5.5.0
