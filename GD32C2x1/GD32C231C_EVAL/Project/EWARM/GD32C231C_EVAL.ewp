# IAR project GD32C231C_EVAL.ewp, settings and files
configuration GD32C2x1 (ARM, debug)
  General.OGChipSelectEditMenu: GD32C231x8 GD GD32C231x8
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 58
  General.FPU2: 0
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER
  ICCARM.CCIncludePath2: ..\..\..\GD32C2x1_Firmware_Library\CMSIS\GD\GD32C2x1\Include; ..\..\Utilities; ..; ..\..\..\GD32C2x1_Firmware_Library\GD32C2x1_standard_peripheral\Include; ..\..\..\GD32C2x1_Firmware_Library\CMSIS\GD\GD32C2x1\Include; ..\..\..\..\Middleware\Third_Party\FreeRTOS-Kernel-11.2.0\include; ..\..\..\..\Middleware\Third_Party\FreeRTOS-Kernel-11.2.0\portable\IAR\ARM_CM23_NTZ\non_secure
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 2
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..; ..\..\..\..\Middleware\Third_Party\FreeRTOS-Kernel-11.2.0\include; ..\..\..\..\Middleware\Third_Party\FreeRTOS-Kernel-11.2.0\portable\IAR\ARM_CM23_NTZ\non_secure
  OBJCOPY.OOCOutputFile: Project.srec
  ILINK.IlinkOutputFile: Project.out
  ILINK.IlinkIcfFile: $TOOLKIT_DIR$\config\linker\GD\GD32C231x8.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application
    ../: gd32c2x1_it.c main.c
  group CMSIS
    ../../../GD32C2x1_Firmware_Library/CMSIS/GD/GD32C2x1/Source/: gd32c2x1_err_report.c system_gd32c2x1.c
  group GD32C2x1_EVAL
    ../../Utilities/: gd32c231c_eval.c
  group GD32C2x1_Peripherals
    ../../../GD32C2x1_Firmware_Library/GD32C2x1_standard_peripheral/Source/: gd32c2x1_adc.c gd32c2x1_cmp.c gd32c2x1_crc.c gd32c2x1_dbg.c gd32c2x1_dma.c gd32c2x1_exti.c gd32c2x1_fmc.c gd32c2x1_fwdgt.c gd32c2x1_gpio.c gd32c2x1_i2c.c gd32c2x1_misc.c gd32c2x1_pmu.c gd32c2x1_rcu.c gd32c2x1_rtc.c gd32c2x1_spi.c gd32c2x1_syscfg.c gd32c2x1_timer.c gd32c2x1_usart.c gd32c2x1_wwdgt.c
  group Startup
    ../../../GD32C2x1_Firmware_Library/CMSIS/GD/GD32C2x1/Source/IAR/: startup_gd32c231_221.s
  group FreeRTOS
    ../../../../Middleware/Third_Party/FreeRTOS-Kernel-11.2.0/: tasks.c queue.c list.c timers.c event_groups.c stream_buffer.c croutine.c
    ../../../../Middleware/Third_Party/FreeRTOS-Kernel-11.2.0/portable/MemMang/: heap_4.c
    ../../../../Middleware/Third_Party/FreeRTOS-Kernel-11.2.0/portable/IAR/ARM_CM23_NTZ/non_secure/: port.c portasm.s
